File: silense.sch (EAGLE design)
At the start: 0 parts

Commit message: merge
Other:
- note removed: "coax connections"
